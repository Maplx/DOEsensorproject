# IAR project CoAP.ewp, settings and files
configuration dtls-security-int-i3 (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: I3_MOTE=1; COAP_MESSAGING_MOD=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; UIP_CONF_TCP=0; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64=1; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; FEATURE_DTLS=1; DTLS_WITH_TIRTOS=1; WITH_SHA256=1; NDEBUG=1; xMAX_NUM_OF_OUTSTANDING_PACKETS=1; xMAX_NUM_OUTSTANDING_UIP_PACKETS=1; MAX_NUM_OUTSTANDING_APP_RX_PACKETS=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/i3mote_cc2650; ../../../Components/sensor; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$-$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: coap_cc26xx_dtls.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd; --keep __vector_table
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; $PROJ_PATH$/../../lib/tsch-int-cc26xx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration dtls-security-int-sensortag (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: COAP_MESSAGING_MOD=1; SENSORTAG=1; xI3_MOTE=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; WITH_ULPSMAC=1; UIP_CONF_TCP=0; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; FEATURE_DTLS=1; DTLS_WITH_TIRTOS=1; WITH_SHA256=1; NDEBUG=1; xMAX_NUM_OF_OUTSTANDING_PACKETS=1; xMAX_NUM_OUTSTANDING_UIP_PACKETS=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/sensortag_cc2650; ../../../Components/sensor; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
configuration tida-01439 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: COAP_MESSAGING_MOD=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; UIP_CONF_TCP=0; xFEATURE_MAC_SECURITY; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Components/hal; ../../../Components/hal/tida01439_cc2650; ../../../Components/sensor; ../../../Components/apps; ../../../Components/uip; ../../../Components/uip/inc; ../../../Components/uip/conf; ../../../Components/uip/pltfrm/sysbios; ../../../Components/uip/uip_rpl_impl/sysbios; ../../../Components/tsch; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: coap_cc26xx.icf
configuration i3-split (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: I3_MOTE_SPLIT_ARCH=1; COAP_MESSAGING_MOD=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; WITH_ULPSMAC=1; UIP_CONF_TCP=0; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1
  ILINK.IlinkIcfFile: coap_cc26xx.icf
configuration sensortag (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: COAP_MESSAGING_MOD=1; NVM_ENABLED=0; SENSORTAG=1; xI3_MOTE=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; UIP_CONF_TCP=0; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xMAX_NUM_OF_OUTSTANDING_PACKETS=1; xMAX_NUM_OUTSTANDING_UIP_PACKETS=1
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: C:\Users\Kefan\Downloads\6TiSCH-Testbed-main (1)\6TiSCH-Testbed-main\source\Projects\tsch\coap-cc26xx\coap_cc26xx.icf
configuration i3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: I3_MOTE=1; COAP_MESSAGING_MOD=1; IS_ROOT=0; IS_INTERMEDIATE=1; WITH_UIP6=1; UIP_CONF_TCP=0; FEATURE_MAC_SECURITY=1; xTSCH_MAC_USE_MAC64; CC26XX_DEVICES=1; PHY_IEEE_MODE=1; xMAX_NUM_OF_OUTSTANDING_PACKETS=1; xMAX_NUM_OUTSTANDING_UIP_PACKETS=1
  ILINK.IlinkIcfFile: coap_cc26xx.icf
  group APP
    ./: main.c
  group APP/coap
    ../../../Components/apps/coap/: address.h async.c async.h bits.h block.c block.h coap.h coap_common_app.c coap_common_app.h coap_gw_app.c coap_host_app.c coap_host_app.h coap_list.c coap_list.h coap_nvm.c coap_time.h config.h debug.c debug.h encode.c encode.h harp.c harp.h hashkey.c hashkey.h mem.h net.c net.h option.c option.h pdu.c pdu.h prng.h resource.c resource.h str.c str.h subscribe.c subscribe.h t_list.h uri.c uri.h uthash.h utlist.h
  group APP/ehest
    ../../../Components/apps/ehest/: ehest.c ehest.h
  group APP/hct_msp432/hct
    ../../../Components/apps/hct_msp432/hct/: hct.c hct.h msp432hct.c msp432hct.h
  group APP/hct_msp432/nwp
    ../../../Components/apps/hct_msp432/nwp/: crc16.c crc16.h nwp.h nwp_cc2650.c nwp_cc2650.h
  group APP/hct_msp432/spi
    ../../../Components/apps/hct_msp432/serialbus/: BusSPI.c BusSPI.h
  group APP/json
    ../../../Components/apps/json/: json.h jsonparse.c jsonparse.h jsontree.c jsontree.h
  group APP/pwrest
    ../../../Components/apps/pwrest/: pwrest.c pwrest.h
  group APP/webmsg
    ../../../Components/apps/webmsg/: webmsg.c webmsg.h
  group CONFIG
    ../../../Components/hal/: ccfg.c
    ./: coap_cc26xx.cfg coap_cc26xx.icf coap_cc26xx_dtls.icf
    ../../../Components/uip/inc/: config-rpl-public.h config-uip-public.h nv_params.h
    ../../../Components/tsch/: mac_config.c mac_config.h nv_params.c
  group HAL
    ../../../Components/hal/: CryptoCC26XX.c CryptoCC26XX.h hal_api.h hal_main.c I2CCC26XX.c I2CCC26XX.h led.h NVS.c NVS.h NVSCC26XX.c NVSCC26XX.h rf_cc26xx.c rf_cc26xx.h rtimer-arch.c rtimer-arch.h
  group HAL/i3mote
    ../../../Components/hal/i3mote_cc2650/: Board.c Board.h led.c
  group HAL/inc
    ../../../Components/hal/inc/: ieee_cmd.h RF.h RFCC26XX_singleMode.c
  group HAL/sensortag
    ../../../Components/hal/sensortag_cc2650/: Board.c Board.h led.c
  group HAL/tida
    ../../../Components/hal/tida01439_cc2650/: Board.c Board.h led.c
  group STACK/DTLS
    ../../../Components/apps/dtls/: alert.h ccm.c ccm.h contiki-conf.h contiki-default-conf.h contiki-lib.h contiki-net.h contiki-version.h contiki.h crypto.c crypto.h debug.h dtls.c dtls.h dtls_config.h dtls_time.c dtls_time.h global.h hmac.c hmac.h netq.c netq.h numeric.h peer.c peer.h prng.h session.c session.h state.h t_list.h tinydtls.h tinydtls.h.in uthash.h utlist.h
    ../../../Components/dtls/: dtls_client.c dtls_client.h
    ../../../Components/apps/dtls/ecc/: ecc.c ecc.h
    ../../../Components/apps/dtls/platform-specific/: platform.h
    ../../../Components/apps/dtls/aes/: rijndael.c rijndael.h
    ../../../Components/apps/dtls/sha2/: sha2.c sha2.h
  group STACK/sensor
    ../../../Components/sensor/: SensorBatMon.c SensorBatMon.h SensorBmp280.c SensorBmp280.h SensorHDC1000.c SensorHDC1000.h SensorI2C.c SensorI2C.h SensorLIS2HH12.c SensorLIS2HH12.h SensorMpu9250.c SensorMpu9250.h SensorSoot.c SensorSoot.h soot_resistance.c soot_resistance.h SensorOpt3001.c SensorOpt3001.h SensorTmp007.c SensorTmp007.h SensorUtil.c SensorUtil.h
  group STACK/TSCH
    ../../../Components/tsch/: nhl_api.c nhl_api.h nhl_setup.c nhl_setup.h
  group STACK/uIP/conf
    ../../../Components/uip/conf/: plat-conf.h rpl-conf.h uip-conf.h
  group STACK/uIP/inc
    ../../../Components/uip/inc/: config-rpl-private.h config-uip-private.h
  group STACK/uIP/lib
    ../../../Components/uip/lib/: list.c list.h memb.c memb.h random.c random.h
  group STACK/uIP/net
    ../../../Components/uip/net/: nbr-table.c nbr-table.h packetbuf.c packetbuf.h queuebuf.c queuebuf.h sicslowpan.c sicslowpan.h tcpip.c tcpip.h udp-simple-socket.c udp-simple-socket.h uip-debug.c uip-debug.h uip-ds6-nbr.c uip-ds6-nbr.h uip-ds6-route.c uip-ds6-route.h uip-ds6.c uip-ds6.h uip-fw.c uip-fw.h uip-icmp6.c uip-icmp6.h uip-nd6.c uip-nd6.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c uip-udp-packet.h uip.h uip6.c uip_arch.h uipopt.h
  group STACK/uIP/pltfrm
    ../../../Components/uip/pltfrm/sysbios/: pltfrm_lib.c pltfrm_lib.h
  group STACK/uIP/rime
    ../../../Components/uip/rime/: rimeaddr.c rimeaddr.h
  group STACK/uIP/rpl
    ../../../Components/uip/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-plusplus.c rpl-plusplus.h rpl-private.h rpl-routing-header.c rpl-routing-header.h rpl-timers.c rpl.c rpl.h rpl_api.h rpl_ipv6_api.h
  group STACK/uIP/sys
    ../../../Components/uip/sys/: clock.c clock.h ctimer.c ctimer.h etimer.c etimer.h process.h stimer.c stimer.h timer.c timer.h
  group STACK/uIP/uip_rpl_impl
    ../../../Components/uip/uip_rpl_impl/: uip_rpl_attributes.c uip_rpl_attributes.h
    ../../../Components/uip/uip_rpl_impl/sysbios/: uip_rpl_process.c uip_rpl_process.h
